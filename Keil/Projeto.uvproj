# Keil uVision project Projeto.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: Projeto
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ../Source/: config.h flags.h lcd.c lcd.h main.c parser.c parser.h pwm.c pwm.h serial.c serial.h
